* EESchema Netlist Version 1.1 (Spice format) creation date: 9/1/2013 7:24:07 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
C17  N-000052 DGND 18pF
C14  N-000051 DGND 18pF
X1  N-000051 N-000052 12.288MHz
R7  PCM_DOUT N-000011 220
R5  PCM_CLK N-000008 220
R8  PCM_DIN N-000010 220
R6  PCM_FS N-000061 220
R9  N-000016 I2C_SDA 220
R11  N-000054 I2C_CLK 220
U6  N-000053 N-000053 VREF LOUT AGND +9VDC N-000046 N-000046 DRV135
C8  RHPOUT N-000048 220uF
C9  LHPOUT N-000049 220uF
R3  N-000048 AGND 10k
R4  N-000049 AGND 10k
C16  N-000050 AGND 100n
C15  N-000050 AGND 10uF
C10  N-000056 AGND 100n
L1  +3.3VDC N-000056 10uH
C13  N-000009 DGND 100n
L2  N-000009 N-000014 10uH
U5  N-000009 ? N-000008 N-000011 N-000061 N-000010 N-000061 +3.3VDC LHPOUT RHPOUT AGND LOUT ROUT N-000056 AGND N-000050 ? ? N-000032 N-000020 N-000019 N-000005 N-000016 N-000054 N-000052 N-000051 N-000009 DGND WM8731
P1  GNDPWR ? 9V DC
J2  ? DVDD PCM_CLK PCM_FS PCM_DIN PCM_DOUT DGND DGND CONN_4X2
C6  +3.3VDC GNDPWR 2.2uF
C2  DC IN GNDPWR 1.0uF
C5  N-000036 GNDPWR 10uF
C3  DC IN GNDPWR 1.0uF
C1  DC IN GNDPWR 1.0uF
U1  DC IN GNDPWR GPIO4 N-000002 +9VDC MIC5207BM5
C4  N-000002 GNDPWR 470pF
R2  GNDPWR N-000002 10k
R1  N-000002 +9VDC 1600
R10  N-000019 N-000007 10k
P2  AGND N-000049 N-000048 Headphone Out
C11  +9VDC AGND 100nF
C12  +9VDC AGND 10uF
C18  +9VDC AGND 100nF
C19  +9VDC AGND 10uF
U4  VREF GNDPWR +9VDC N-000013 TLE2426
C7  N-000013 GNDPWR 1.0uF
J3  DGND PCM_CLK PCM_DIN PCM_DOUT PCM_FS GPIO4 I2C_CLK I2C_SDA PIN OUT
R12  N-000005 N-000001 10k
P5  DGND DGND N-000001 N-000007 DVDD DVDD MODE SET
U2  DC IN GNDPWR N-000036 MIC39100-5.0
U3  DC IN GNDPWR GPIO4 ? +3.3VDC MIC5225
J1  ? N-000035 I2C_SDA N-000035 I2C_CLK DGND GPIO4 ? DGND ? ? ? ? DGND ? ? ? ? ? DGND ? ? ? ? DGND ? RASPI_IO_HEADER
U7  N-000065 N-000065 VREF ROUT AGND +9VDC N-000066 N-000066 DRV135
P6  AGND N-000066 N-000065 CONNECTOR_3
P3  AGND N-000046 N-000053 CONNECTOR_3
P4  AGND N-000032 N-000020 CONNECTOR_3
F1  ? DC IN PolyFuse
D1  GNDPWR DC IN SMAJ12A
J4  DVDD N-000014 N-000036 ? Power
LD4  +3.3VDC N-000029 Green
R15  GNDPWR N-000029 750
LD3  N-000036 N-000030 Green
R14  GNDPWR N-000030 1k6
R16  N-000026 ? 3k9
LD2  N-000026 GNDPWR Green
LD1  ? N-000024 Red
R13  GNDPWR N-000024 3k6
LD5  GPIO4 N-000028 Green
R17  N-000028 DGND 750

.end
